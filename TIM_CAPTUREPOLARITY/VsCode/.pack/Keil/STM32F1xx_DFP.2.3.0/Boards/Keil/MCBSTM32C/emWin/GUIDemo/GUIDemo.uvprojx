# Keil uVision project GUIDemo.uvprojx, settings and files
target MCBSTM32C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0-dev7
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GUIDemo
  c flags: Optim=4
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32C LCD_LG (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0-dev7
  cpu: as above
  output: GUIDemo
  c flags: Optim=4
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.79.0, Board Support:Joystick 2.0.0, Board Support:Touchscreen 2.0.0, Board Support:emWin LCD 2.0.0, CMSIS Driver:I2C 2.0, CMSIS Driver:SPI 2.0, Device:DMA 1.1, Device:GPIO 1.1, Device:Startup 1.0.0, Graphics:CORE 5.30.0, Graphics:Demo:Automotive 5.30.0, Graphics:Demo:ColorBar 5.30.0, Graphics:Demo:Cursor 5.30.0, Graphics:Demo:Framework 5.30.0, Graphics:Demo:Graph 5.30.0, Graphics:Demo:ListView 5.30.0, Graphics:Demo:Speed 5.30.0, Graphics:Demo:TransparentDialog 5.30.0, Graphics:Display:MCBQVGA_LD 5.30.0, Graphics:Display:MCBQVGA_LG 5.30.0, Graphics:Input Device:Joystick 5.30.0, Graphics:Input Device:Touchscreen 5.30.0
