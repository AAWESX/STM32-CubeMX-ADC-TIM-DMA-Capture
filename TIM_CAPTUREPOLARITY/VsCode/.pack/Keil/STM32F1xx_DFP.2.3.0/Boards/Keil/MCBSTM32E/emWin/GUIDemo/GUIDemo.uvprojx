# Keil uVision project GUIDemo.uvprojx, settings and files
target MCBSTM32E (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0-dev7
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GUIDemo
  c flags: Optim=4
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32E LCD_LG (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0-dev7
  cpu: as above
  output: GUIDemo
  c flags: Optim=4
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, Board Support:Joystick 2.0.0, Board Support:emWin LCD 2.0.0, Device:GPIO 1.3, Device:Startup 1.0.0, Graphics:CORE 5.42.9, Graphics:Demo:Automotive 5.42.9, Graphics:Demo:ColorBar 5.42.9, Graphics:Demo:Cursor 5.42.9, Graphics:Demo:Framework 5.42.9, Graphics:Demo:Graph 5.42.9, Graphics:Demo:ListView 5.42.9, Graphics:Demo:Speed 5.42.9, Graphics:Demo:TransparentDialog 5.42.9, Graphics:Display:MCBQVGA_LD 5.42.9, Graphics:Display:MCBQVGA_LG 5.42.9, Graphics:Input Device:Joystick 5.42.9
